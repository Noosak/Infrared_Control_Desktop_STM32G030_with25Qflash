# Keil uVision project Infrared_Control.uvprojx, settings and files
target Infrared_Control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Infrared_Control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32G030xx,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,PREFETCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Corp_File/Device/25Flash;../Corp_File/Device/CMT2300A;../Corp_File/Device/Inc;../Corp_File/RTE/GnLink;../Corp_File/RTE/HAL/Inc;../Corp_File/RTE/StateMachine/Inc;../Corp_File/Task/Inc;../Corp_File/Task/Api/IRcodeHandler/inc;../Corp_File/RTE/HAL/api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_dma.c stm32g0xx_ll_spi.c stm32g0xx_ll_rcc.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Device/25QFLASH
    ../Corp_File/Device/25Flash/: 25QFlash.c
  group RTE/StateMechine
    ../Corp_File/RTE/GnLink/: gen_link_list.c
    ../Corp_File/RTE/StateMachine/Src/: HAL_SM_InitTask_API.c HAL_SM_MainLoop.c
  group RTE/HAL
    ../Corp_File/RTE/HAL/Src/: HAL_Control_UART.c HAL_Control_SPI.c HAL_Control_GPIO.c HAL_Control_Export_API.c HAL_Control_Error.c
  group Device(Old OperationFunc)
    ../Corp_File/Device/Src/: api_rf_comm.c api_work_state.c driver_flash.c driver_key.c driver_memory.c system_queue.c sha3.c
  group Task
    ../Corp_File/Task/Src/: Task_433Communicate.c Task_CommonFile.c Task_Key.c Task_LED.c Task_Serial.c Task_IREmit.c
  group Device/2300A
    ../Corp_File/Device/CMT2300A/: cmt_spi3.c cmt2300a.c cmt2300a_hal.c gpio_defs.c radio.c
  group Task/SerialAndIRcodeHandler
    ../Corp_File/Task/Api/IRcodeHandler/src/: ircode_catch.c ircode_emit.c serialctrl_handler.c serialctrl_ircaddrproc.c serialctrl_memopt.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
